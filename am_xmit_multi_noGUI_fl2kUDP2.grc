options:
  parameters:
    generate_options: no_gui
    id: am_xmit_multi_carrier_fl2k
    output_language: python
  states: {}

blocks:
- name: af_sample_rate
  id: variable
  parameters:
    value: 22e3
  states: {}
- name: fgain
  id: variable
  parameters:
    value: '250'
  states: {}
- name: fir_interp
  id: variable
  parameters:
    value: (int)(rf_sample_rate/af_sample_rate)
  states: {}
- name: rf_sample_rate
  id: variable
  parameters:
    value: 2048e3
  states: {}
- name: start_rf
  id: variable
  parameters:
    value: 0e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+1
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+90e3
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 531e3
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate*4
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(2*90e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(3*90e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_4
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(4*90e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_5
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(5*90e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_5_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(6*90e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_5_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(7*90e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_5_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(8*90e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_5_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(10*90e3)+(1*45e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_5_1_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(10*90e3)+(2*45e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_5_1_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(9*90e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_5_1_0_1_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(10*90e3)+(3*45e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_5_1_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: start_rf+(10*90e3)
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_2
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_3
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_4
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_5
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_5_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_5_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_5_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_5_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_5_1_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_5_1_0_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_5_1_0_1_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_5_1_0_2
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_1_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '128'
  states: {}
- name: blocks_multiply_const_vxx_6
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.15'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_4
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_1_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_1_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_1_0_1_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_1_0_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_6
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_3
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_4
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_5
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_5_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_5_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_5_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_5_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_5_1_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_5_1_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_5_1_0_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_5_1_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    gain: fgain
    interp: fir_interp
    samp_rate: rf_sample_rate
    type: interp_fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '25000'
    type: byte
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2601'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2602'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2603'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2604'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2605'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2606'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0_0_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2607'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0_0_0_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2608'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0_0_0_0_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2612'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0_0_0_0_0_1
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2613'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0_0_0_0_0_1_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2610'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0_0_0_0_0_1_1
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2614'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0_0_0_0_0_2
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2611'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_1
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '2609'
    src_zeros: 'False'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_6, '1']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_2, '1']
- [analog_sig_source_x_3, '0', blocks_multiply_xx_3, '1']
- [analog_sig_source_x_4, '0', blocks_multiply_xx_4, '1']
- [analog_sig_source_x_5, '0', blocks_multiply_xx_5, '1']
- [analog_sig_source_x_5_0, '0', blocks_multiply_xx_5_0, '1']
- [analog_sig_source_x_5_1, '0', blocks_multiply_xx_5_1, '1']
- [analog_sig_source_x_5_1_0, '0', blocks_multiply_xx_5_1_0, '1']
- [analog_sig_source_x_5_1_0_0, '0', blocks_multiply_xx_5_1_0_0, '1']
- [analog_sig_source_x_5_1_0_1, '0', blocks_multiply_xx_5_1_0_1, '1']
- [analog_sig_source_x_5_1_0_1_0, '0', blocks_multiply_xx_5_1_0_1_0, '1']
- [analog_sig_source_x_5_1_0_1_1, '0', blocks_multiply_xx_5_1_0_1_1, '1']
- [analog_sig_source_x_5_1_0_2, '0', blocks_multiply_xx_5_1_0_2, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_multiply_xx_1, '0']
- [blocks_add_const_vxx_2, '0', blocks_multiply_xx_2, '0']
- [blocks_add_const_vxx_3, '0', blocks_multiply_xx_3, '0']
- [blocks_add_const_vxx_4, '0', blocks_multiply_xx_4, '0']
- [blocks_add_const_vxx_5, '0', blocks_multiply_xx_5, '0']
- [blocks_add_const_vxx_5_0, '0', blocks_multiply_xx_5_0, '0']
- [blocks_add_const_vxx_5_1, '0', blocks_multiply_xx_5_1, '0']
- [blocks_add_const_vxx_5_1_0, '0', blocks_multiply_xx_5_1_0, '0']
- [blocks_add_const_vxx_5_1_0_0, '0', blocks_multiply_xx_5_1_0_0, '0']
- [blocks_add_const_vxx_5_1_0_1, '0', blocks_multiply_xx_5_1_0_1, '0']
- [blocks_add_const_vxx_5_1_0_1_0, '0', blocks_multiply_xx_5_1_0_1_0, '0']
- [blocks_add_const_vxx_5_1_0_1_1, '0', blocks_multiply_xx_5_1_0_1_1, '0']
- [blocks_add_const_vxx_5_1_0_2, '0', blocks_multiply_xx_5_1_0_2, '0']
- [blocks_add_xx_0, '0', blocks_add_xx_2, '0']
- [blocks_add_xx_1, '0', blocks_add_xx_2, '1']
- [blocks_add_xx_1_0, '0', blocks_add_xx_2, '3']
- [blocks_add_xx_1_1, '0', blocks_add_xx_2, '2']
- [blocks_add_xx_2, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_char_0, '0', network_tcp_sink_0, '0']
- [blocks_multiply_const_vxx_6, '0', blocks_float_to_char_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_2, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_3, '0', blocks_add_xx_0, '3']
- [blocks_multiply_xx_4, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_5, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_5_0, '0', blocks_add_xx_1, '2']
- [blocks_multiply_xx_5_1, '0', blocks_add_xx_1_1, '0']
- [blocks_multiply_xx_5_1_0, '0', blocks_add_xx_1_1, '1']
- [blocks_multiply_xx_5_1_0_0, '0', blocks_add_xx_1_0, '1']
- [blocks_multiply_xx_5_1_0_1, '0', blocks_add_xx_1_0, '2']
- [blocks_multiply_xx_5_1_0_1_0, '0', blocks_add_xx_1_1, '2']
- [blocks_multiply_xx_5_1_0_1_1, '0', blocks_add_xx_1_0, '3']
- [blocks_multiply_xx_5_1_0_2, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_xx_6, '0', blocks_multiply_const_vxx_6, '0']
- [low_pass_filter_0, '0', blocks_add_const_vxx_0, '0']
- [low_pass_filter_1, '0', blocks_add_const_vxx_1, '0']
- [low_pass_filter_2, '0', blocks_add_const_vxx_2, '0']
- [low_pass_filter_3, '0', blocks_add_const_vxx_3, '0']
- [low_pass_filter_4, '0', blocks_add_const_vxx_4, '0']
- [low_pass_filter_5, '0', blocks_add_const_vxx_5, '0']
- [low_pass_filter_5_0, '0', blocks_add_const_vxx_5_0, '0']
- [low_pass_filter_5_1, '0', blocks_add_const_vxx_5_1, '0']
- [low_pass_filter_5_1_0, '0', blocks_add_const_vxx_5_1_0, '0']
- [low_pass_filter_5_1_0_0, '0', blocks_add_const_vxx_5_1_0_0, '0']
- [low_pass_filter_5_1_0_1, '0', blocks_add_const_vxx_5_1_0_1, '0']
- [low_pass_filter_5_1_0_1_0, '0', blocks_add_const_vxx_5_1_0_1_0, '0']
- [low_pass_filter_5_1_0_1_1, '0', blocks_add_const_vxx_5_1_0_1_1, '0']
- [low_pass_filter_5_1_0_2, '0', blocks_add_const_vxx_5_1_0_2, '0']
- [network_udp_source_0, '0', low_pass_filter_0, '0']
- [network_udp_source_0_0, '0', low_pass_filter_2, '0']
- [network_udp_source_0_0_0, '0', low_pass_filter_3, '0']
- [network_udp_source_0_0_0_0, '0', low_pass_filter_4, '0']
- [network_udp_source_0_0_0_0_0, '0', low_pass_filter_5, '0']
- [network_udp_source_0_0_0_0_0_0, '0', low_pass_filter_5_0, '0']
- [network_udp_source_0_0_0_0_0_0_0, '0', low_pass_filter_5_1, '0']
- [network_udp_source_0_0_0_0_0_0_0_0, '0', low_pass_filter_5_1_0, '0']
- [network_udp_source_0_0_0_0_0_0_0_0_0, '0', low_pass_filter_5_1_0_0, '0']
- [network_udp_source_0_0_0_0_0_0_0_0_1, '0', low_pass_filter_5_1_0_1, '0']
- [network_udp_source_0_0_0_0_0_0_0_0_1_0, '0', low_pass_filter_5_1_0_1_0, '0']
- [network_udp_source_0_0_0_0_0_0_0_0_1_1, '0', low_pass_filter_5_1_0_1_1, '0']
- [network_udp_source_0_0_0_0_0_0_0_0_2, '0', low_pass_filter_5_1_0_2, '0']
- [network_udp_source_0_1, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_6, '0']

metadata:
  file_format: 1
